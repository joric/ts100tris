# IAR project App.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103x8 ST STM32F103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD; APP_MODE; TYPE_S100; OLED_VGM096016A3W07; VIRTUAL_DISK
  ICCARM.CCIncludePath2: Inc; Src; ..\Libraries\CMSIS\Device\STM32F10x\Include; ..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\Libraries\STM32_USB-FS-Device_Driver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: APP.hex
  ILINK.IlinkOutputFile: APP.out
  ILINK.IlinkIcfFile: STM32F103_APP.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: App.out
  group MSD
    Src/: USB_bot.c USB_desc.c USB_istr.c USB_prop.c USB_pwr.c USB_scsi.c
  group Pawn
    ../Pawn/: amx.c amx.h amxexec_thumb2_iar.s amxfuncs.c amxfuncs.h osdefs.h pawn.h pawnconf.h
  group Prgm
    Src/: Bios.c CTRL.c Disk.c Ext_Flash.c Flash.c HARDWARE.c I2C.c Interrupt.c Main.c MMA8652FC.c Oled.c own_sprintf.c UI.c
  group STM32F10x/CMSIS
    Src/: STM32F103_Startup.s STM32F103_System.c
  group STM32F10x/StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USB-FS-Devier
    ../Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
